# Keil uVision project 51MCU_GPIO_Use.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 51MCU_GPIO_Use +hex
  c flags: Optimize=8 SizeSpeed=1
  group Assembly
    ./src/: STARTUP.A51
  group Source code
    ./src/: Main.a51
